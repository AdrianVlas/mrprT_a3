<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\v.17.00\device_2_v_17_1_0_0.ewp</path>
    </project>
    <batchBuild />
</workspace>
